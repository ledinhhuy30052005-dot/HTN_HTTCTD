# Keil uVision project Greenhouse_APP.uvprojx, settings and files
target Greenhouse_APP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x0800C800,0x00013000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: greenhouse_app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VECT_TAB_OFFSET=0xC800
  c include: ..\user;..\config;..\task;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\freertos_add\include;.\freertos_add;.\RTE\Device\STM32F103C8;.\RTE
  memory RVCT4: ROM 0x0800C800 size 0x00013000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c
  group config
    ../config/: analog_input.c app_state.c bh1750.c board.c button.c buzzer.c config_store.c dht11.c ds3231.c freertos_hooks.c i2c_bus.c oled.c relay.c sensors.c soil_sensor.c water_sensor.c analog_input.h app_config.h app_state.h app_types.h bh1750.h board.h button.h buzzer.h config_store.h dht11.h ds3231.h i2c_bus.h oled.h relay.h sensors.h soil_sensor.h water_sensor.h
  group taskN1
    ../task/: taskN1.c taskN1.h
  group taskN2
    ../task/: taskN2.c taskN2.h
  group taskN3
    ../task/: taskN3.c taskN3.h
  group lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Lib/CMSIS/CM3/CoreSupport/: stm32f10x_conf.h
  group free_rtos
    ./freertos_add/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
    ./freertos_add/include/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
