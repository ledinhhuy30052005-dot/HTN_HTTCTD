# Keil uVision project TaskN3_Standalone.uvprojx, settings and files
target TaskN3_Standalone (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x0800C800,0x00013000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TaskN3_Standalone +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VECT_TAB_OFFSET=0xC800
  c include: ..\user;..\config;..\task;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\freertos_add\include;.\freertos_add;.\RTE\Device\STM32F103C8;.\RTE
  memory RVCT4: ROM 0x0800C800 size 0x00013000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c task3_standalone.c task3_standalone.h
  group config
    ../config/: analog_input.c analog_input.h app_config.h app_state.c app_state.h app_types.h bh1750.c bh1750.h board.c board.h button.c button.h buzzer.c buzzer.h config_store.c config_store.h dht11.c dht11.h ds3231.c ds3231.h freertos_hooks.c i2c_bus.c i2c_bus.h relay.c relay.h sensors.c sensors.h soil_sensor.c soil_sensor.h water_sensor.c water_sensor.h
  group taskN3
    ../task/: taskN3.c taskN3.h
  group lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c
    ./Lib/CMSIS/CM3/CoreSupport/: stm32f10x_conf.h
  group free_rtos
    ./freertos_add/: heap_2.c list.c port.c queue.c tasks.c
    ./freertos_add/include/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
